## fs/bkpfs/Kconfig
```kconfig
config BKP_FS
	tristate "Bkpfs stackable file system (EXPERIMENTAL)"
	help
	  Bkpfs is a stackable file system which creates version of files when opened.
```
